require aws-sdk-cpp.inc

EXTRA_OECMAKE += "-DBUILD_ONLY=lex"
