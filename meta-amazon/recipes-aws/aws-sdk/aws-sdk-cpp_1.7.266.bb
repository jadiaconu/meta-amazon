require aws-sdk-cpp.inc

DESCRIPTION = "AWS SDK for C++"
AUTHOR = "AWS"
HOMEPAGE = "https://aws.amazon.com/fr/sdk-for-cpp/"
